# Keil uVision project nRF2460-DK.uvproj, settings and files
target nRF2460-DK (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: nRF2460-DK +hex
  c flags: Optimize=9
  c include: .\Include
  group App
    ./: main.c config.c macro.c
  group HAL
    ./Include/: hal_w2.c
