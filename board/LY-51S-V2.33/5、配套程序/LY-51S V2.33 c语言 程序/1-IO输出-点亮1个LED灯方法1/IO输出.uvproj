# Keil uVision project IO输出.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C516RD+ STC-STC90
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xF3FF) CLOCK(45000000) MODP2
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 点亮1个led方法1.c
