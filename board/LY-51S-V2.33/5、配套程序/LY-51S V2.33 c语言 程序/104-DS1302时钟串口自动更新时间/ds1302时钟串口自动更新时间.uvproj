# Keil uVision project ds1302时钟串口自动更新时间.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C516RD+ STC-STC90
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xF3FF) CLOCK(45000000) MODP2
  output: ds1302时钟串口自动更新时间 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS1302.c main.c
