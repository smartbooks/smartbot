# Keil uVision project 喇叭发声原理.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C516RD+ STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xF7FF) CLOCK(45000000) MODP2
  output: 喇叭发声原理 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 喇叭发声原理.c
