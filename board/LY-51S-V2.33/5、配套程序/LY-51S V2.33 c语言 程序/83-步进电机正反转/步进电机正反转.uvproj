# Keil uVision project 步进电机正反转.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C516RD+ STC-STC90
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xF3FF) CLOCK(45000000) MODP2
  output: 步进电机正反转 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 步进电机正反转.c
