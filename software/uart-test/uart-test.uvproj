# Keil uVision project uart-test.uvproj, settings and files
target STC15FXXX (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: uart-test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\tool\Keil_v5_c51_stc\C51\INC;.\src;D:\tool\Keil_v5_c51_stc\C51\INC\STC
  group src
    ./src/: delay.c main.c
