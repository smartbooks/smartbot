# Keil uVision project smartbot-ds1302.uvproj, settings and files
target smartbot-ds1302 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: smartbot-ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;D:\tool\Keil_v5_c51_stc\C51\INC
  group src
    ./src/: main.c delay.c uart.c DS1302.c
