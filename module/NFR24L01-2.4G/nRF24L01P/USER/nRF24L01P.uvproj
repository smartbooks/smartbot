# Keil uVision project nRF24L01P.uvproj, settings and files
target nRF24L01P (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: nRF24L01P +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\24L01;..\FWLib;D:\tool\Keil_v5_c51_stc\C51\INC
  group USER
    ./: main.c uart.h uart.c
  group 24L01
    ../24L01/: nRF24L01P.c nRF24L01P.h
  group FWLib
    ../FWLib/: delay.c delay.h config.h typedef.h
  group README
    ../: README.txt
