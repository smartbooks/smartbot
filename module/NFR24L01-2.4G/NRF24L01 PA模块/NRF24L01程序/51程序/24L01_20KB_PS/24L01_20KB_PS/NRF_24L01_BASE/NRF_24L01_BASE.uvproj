# Keil uVision project NRF_24L01_BASE.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12LE5A60S2 STC12LE5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000)
  output: NRF_24L01_BASE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: NRF_24L01.C UART.C MAIN.C
