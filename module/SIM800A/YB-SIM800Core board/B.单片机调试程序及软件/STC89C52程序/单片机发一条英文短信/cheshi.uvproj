# Keil uVision project cheshi.uvproj, settings and files
target Target 1 (MCS-51)
  device: SM5964 SyncMOS
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: GSM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 cheshi.C
