# Keil uVision project tc35.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0 - 0xFF) XRAM(0- 0xFF) IROM(0 - 0x1FFF) CLOCK(25000000)
  output: tc35 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
